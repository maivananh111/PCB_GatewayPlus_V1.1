File: LTDC_LCD.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J1 LTDC_LCD_FPC_40p

Commit message: Only 1 wire to complete.
Connections:
- net GND: now also J1.41 (PAD), J1.42 (PAD)
