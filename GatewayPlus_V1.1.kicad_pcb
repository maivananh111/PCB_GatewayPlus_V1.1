# Repository maivananh111/PCB_GatewayPlus_V1.1

## KiCad design GatewayPlus_V1.1.kicad_pcb

Parts:
H1, H2, H3, H4: Hole; MountingHole_3.2mm_M3_Pad_Via
JP2: J_TXD0; Jump3_0603_Open
JP4: J_TXD1; Jump3_0603_Open
JP5: J_TXEN; Jump3_0603_Open
JP6: J_RXD0; Jump3_0603_Open
JP7: J_RXD1; Jump3_0603_Open
JP8: J_CRS_DV; Jump3_0603_Open
JP9: J_MDIO; Jump3_0603_Open
JP10: J_MDC; Jump3_0603_Open
JP11: J_CLKEN; Jump3_0603_Open
JP12: J_REFCLK; Jump3_0603_Open

Connections:
/ETH/ETH_CLKEN: JP11.2 (C); also elsewhere on the board
/ETH/ETH_REFCLK: JP12.2 (C); also elsewhere on the board
/ETH/RMII_CRS_DV: JP8.2 (C); also elsewhere on the board
/ETH/RMII_MDC: JP10.2 (C); also elsewhere on the board
/ETH/RMII_MDIO: JP9.2 (C); also elsewhere on the board
/ETH/RMII_RXD0: JP6.2 (C); also elsewhere on the board
/ETH/RMII_RXD1: JP7.2 (C); also elsewhere on the board
/ETH/RMII_TXD0: JP2.2 (C); also elsewhere on the board
/ETH/RMII_TXD1: JP4.2 (C); also elsewhere on the board
/ETH/RMII_TXEN: JP5.2 (C); also elsewhere on the board
/MCU/ETH_CLKEN: JP11.1 (A); also elsewhere on the board
/MCU/ETH_REFCLK: JP12.1 (A); also elsewhere on the board
/MCU/RMII_CRS_DV: JP8.1 (A); also elsewhere on the board
/MCU/RMII_MDC: JP10.1 (A); also elsewhere on the board
/MCU/RMII_MDIO: JP9.1 (A); also elsewhere on the board
/MCU/RMII_RXD0: JP6.1 (A); also elsewhere on the board
/MCU/RMII_RXD1: JP7.1 (A); also elsewhere on the board
/MCU/RMII_TXD0: JP2.1 (A); also elsewhere on the board
/MCU/RMII_TXD1: JP4.1 (A); also elsewhere on the board
/MCU/RMII_TXEN: JP5.1 (A); also elsewhere on the board
/USB/WiFi_BOOT: JP12.3 (B); also elsewhere on the board
/WIFI ESP32/ETH_CLKEN: JP11.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_CRSDV: JP8.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_MDC: JP10.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_MDIO: JP9.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_RXD0: JP6.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_RXD1: JP7.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_TXD0: JP2.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_TXD1: JP4.3 (B); also elsewhere on the board
/WIFI ESP32/RMII_TXEN: JP5.3 (B); also elsewhere on the board
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Parts:
C71, C72: C_Small; C_0603_1608Metric
C73: C_Small; C_1206_3216Metric
D3: RS_Tx; LED_0603_1608Metric
D4: RS_Rx; LED_0603_1608Metric
D5, D6, D7: D_TVS; D_SMA
F1, F2: Fuse; Fuse_1812_4532Metric
J6: RS485; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
R34, R35, R36, R37, R38, R39, R40, R41: R_Small; R_0603_1608Metric
R42: 120; R_0805_2012Metric
U8: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C71.1, C72.1, C73.1, R39.2, R41.1, U8.8 (VCC); also elsewhere on the board
/MCU/RS485_TE: R37.1; also elsewhere on the board
/MCU/USART2_RX: R35.1, R36.1; also elsewhere on the board
/MCU/USART2_TX: R34.1, R38.1; also elsewhere on the board
/RS485/A+: F2.2, J6.2, R42.1
/RS485/B-: F1.2, J6.3, R42.2
GND: C71.2, C72.2, C73.2, D5.2 (A2), D7.2 (A2), J6.1, R40.2, U8.5 (GND); also elsewhere on the board
unnamed: D3.1 (K), R34.2
unnamed: D4.1 (K), R35.2
unnamed: D5.1 (A1), D6.2 (A2), F1.1, R40.1, U8.7 (B)
unnamed: D6.1 (A1), D7.1 (A1), F2.1, R41.2, U8.6 (A)
unnamed: R36.2, R39.1, U8.1 (RO)
unnamed: R37.2, U8.2 (~RE), U8.3 (DE)
unnamed: R38.2, U8.4 (DI)

Parts:
C56: 1uF; C_0603_1608Metric
C57, C58: 100nF; C_0603_1608Metric
U3: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm

Connections:
/MCU/FLASH_CS: U3.1 (~CS); also elsewhere on the board
/MCU/SPI1_MISO: U3.2 (DO(IO1)); also elsewhere on the board
/MCU/SPI1_MOSI: U3.5 (DI(IO0)); also elsewhere on the board
/MCU/SPI1_SCK: U3.6 (CLK); also elsewhere on the board
GND: C56.1, C57.1, C58.1, U3.4 (GND); also elsewhere on the board

Parts:
C74, C75, C79, C80, C85, C86: C_Small; C_0603_1608Metric
C76, C78, C81, C82, C83, C84, C87, C88: C_Small; C_1206_3216Metric
C77: 220uF; CP_Elec_8x10.5
D8, D9, D10: SS34; D_SMA
F3: Fuse_Small; Fuse_1206_3216Metric
IC1, IC2: MP1584EN; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
J7: Conn_Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
JP13: 5V_EN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP14: 3V3_EN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L4, L5: L_Ferrite_Small; L_Abracon_ASPI-0630LR
R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54: R_Small; R_0603_1608Metric
RV1: Varistor; RV_Disc_D9mm_W3.3mm_P5mm

Connections:
+5V: JP13.2 (B); also elsewhere on the board
GND: C76.1, C77.2, C78.1, C81.1, C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, D8.2 (A), D9.2 (A), D10.2 (A), IC1.5 (GND), IC1.9 (EP), IC2.5 (GND), IC2.9 (EP), J7.2, J7.3, R44.2, R45.2, R46.2, R47.2, R50.2, R51.2, R52.2, R53.2, RV1.2; also elsewhere on the board
unnamed: C74.1, IC1.8 (BST)
unnamed: C74.2, D9.1 (K), IC1.1 (SW), L4.1
unnamed: C75.1, R46.1
unnamed: C75.2, IC1.3 (COMP)
unnamed: C76.2, C78.2, C83.2, C88.2, JP14.1 (A), L4.2, R48.2
unnamed: C79.1, IC2.8 (BST)
unnamed: C79.2, D10.1 (K), IC2.1 (SW), L5.1
unnamed: C80.1, R52.1
unnamed: C80.2, IC2.3 (COMP)
unnamed: C81.2, C82.2, C84.2, C87.2, JP13.1 (A), L5.2, R54.2
unnamed: F3.1, J7.1
unnamed: IC1.2 (EN), R43.2, R44.1
unnamed: IC1.4 (FB), R47.1, R48.1
unnamed: IC1.6 (FREQ), R45.1
unnamed: IC2.2 (EN), R49.2, R50.1
unnamed: IC2.4 (FB), R53.1, R54.1
unnamed: IC2.6 (FREQ), R51.1
VCC: C77.1, C85.2, C86.2, D8.1 (K), F3.2, IC1.7 (VIN), IC2.7 (VIN), R43.1, R49.1, RV1.1

Parts:
J1: LTDC_LCD_FPC_40p; FPC_40p_Vertical
R10: 220; R_0603_1608Metric

Connections:
+5V: J1.39 (5V); also elsewhere on the board
/LTDC TFT LCD/LCD_BACKGROUND_LED: R10.1; also elsewhere on the board
/LTDC TFT LCD/LTDC_B0: J1.15 (B0); also elsewhere on the board
/LTDC TFT LCD/LTDC_B1: J1.14 (B1); also elsewhere on the board
/LTDC TFT LCD/LTDC_B2: J1.13 (B2); also elsewhere on the board
/LTDC TFT LCD/LTDC_B3: J1.12 (B3); also elsewhere on the board
/LTDC TFT LCD/LTDC_B4: J1.11 (B4); also elsewhere on the board
/LTDC TFT LCD/LTDC_B5: J1.10 (B5); also elsewhere on the board
/LTDC TFT LCD/LTDC_B6: J1.9 (B6); also elsewhere on the board
/LTDC TFT LCD/LTDC_B7: J1.8 (B7); also elsewhere on the board
/LTDC TFT LCD/LTDC_DE: J1.5 (DE); also elsewhere on the board
/LTDC TFT LCD/LTDC_G0: J1.23 (G0); also elsewhere on the board
/LTDC TFT LCD/LTDC_G1: J1.22 (G1); also elsewhere on the board
/LTDC TFT LCD/LTDC_G2: J1.21 (G2); also elsewhere on the board
/LTDC TFT LCD/LTDC_G3: J1.20 (G3); also elsewhere on the board
/LTDC TFT LCD/LTDC_G4: J1.19 (G4); also elsewhere on the board
/LTDC TFT LCD/LTDC_G5: J1.18 (G5); also elsewhere on the board
/LTDC TFT LCD/LTDC_G6: J1.17 (G6); also elsewhere on the board
/LTDC TFT LCD/LTDC_G7: J1.16 (G7); also elsewhere on the board
/LTDC TFT LCD/LTDC_HSYNC: J1.7 (HSYNC); also elsewhere on the board
/LTDC TFT LCD/LTDC_PCLK: J1.33 (PCLK); also elsewhere on the board
/LTDC TFT LCD/LTDC_R0: J1.31 (R0); also elsewhere on the board
/LTDC TFT LCD/LTDC_R1: J1.30 (R1); also elsewhere on the board
/LTDC TFT LCD/LTDC_R2: J1.29 (R2); also elsewhere on the board
/LTDC TFT LCD/LTDC_R3: J1.28 (R3); also elsewhere on the board
/LTDC TFT LCD/LTDC_R4: J1.27 (R4); also elsewhere on the board
/LTDC TFT LCD/LTDC_R5: J1.26 (R5); also elsewhere on the board
/LTDC TFT LCD/LTDC_R6: J1.25 (R6); also elsewhere on the board
/LTDC TFT LCD/LTDC_R7: J1.24 (R7); also elsewhere on the board
/LTDC TFT LCD/LTDC_VSYNC: J1.6 (VSYNC); also elsewhere on the board
/LTDC TFT LCD/TOUCH_INT: J1.38 (T_INT); also elsewhere on the board
/LTDC TFT LCD/TOUCH_SCL: J1.36 (T_SCL); also elsewhere on the board
/LTDC TFT LCD/TOUCH_SDA: J1.37 (T_SDA); also elsewhere on the board
GND: J1.2 (LED-), J1.3 (GND), J1.32 (GND), J1.34 (GND), J1.40 (GND); also elsewhere on the board
unnamed: J1.1 (LED+), R10.2

Parts:
C1, C2, C3, C4, C5, C8, C9: C_Small; C_0603_1608Metric
C6, C7: 22pF; C_0603_1608Metric
C10, C15, C16, C18, C47, C50, C53, C59: 1uF; C_0603_1608Metric
C11, C12, C13, C14, C17, C19, C20, C21, C48, C49, C51, C52, C54, C55, C60, C61: 100nF; C_0603_1608Metric
C118: 10uF; C_1206_3216Metric
D1: LED; LED_0603_1608Metric
J4: SWD_LOG; PinHeader_2x03_P2.54mm_Horizontal
JP3: BOOT; Jump3_0603_Open
R3, R4, R6, R7, R11: R_Small; R_0603_1608Metric
R8: 4k7; R_0603_1608Metric
R9: 4K7; R_0603_1608Metric
SW1: SW_Push; SW_SPST_CK_RS282G05A3
U1: STM32F429IGTx; LQFP-176_24x24mm_P0.5mm
Y1: 32.768KHz; MC306327680KE3ROHS
Y2: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+BATT: U1.6 (VBAT)
/LTDC TFT LCD/LCD_BACKGROUND_LED: U1.138 (PA15); also elsewhere on the board
/LTDC TFT LCD/LTDC_B0: U1.3 (PE4); also elsewhere on the board
/LTDC TFT LCD/LTDC_B1: U1.155 (PG12); also elsewhere on the board
/LTDC TFT LCD/LTDC_B2: U1.153 (PG10); also elsewhere on the board
/LTDC TFT LCD/LTDC_B3: U1.154 (PG11); also elsewhere on the board
/LTDC TFT LCD/LTDC_B4: U1.173 (PI4); also elsewhere on the board
/LTDC TFT LCD/LTDC_B5: U1.174 (PI5); also elsewhere on the board
/LTDC TFT LCD/LTDC_B6: U1.175 (PI6); also elsewhere on the board
/LTDC TFT LCD/LTDC_B7: U1.176 (PI7); also elsewhere on the board
/LTDC TFT LCD/LTDC_DE: U1.28 (PF10); also elsewhere on the board
/LTDC TFT LCD/LTDC_G0: U1.4 (PE5); also elsewhere on the board
/LTDC TFT LCD/LTDC_G1: U1.5 (PE6); also elsewhere on the board
/LTDC TFT LCD/LTDC_G2: U1.128 (PH13); also elsewhere on the board
/LTDC TFT LCD/LTDC_G3: U1.129 (PH14); also elsewhere on the board
/LTDC TFT LCD/LTDC_G4: U1.130 (PH15); also elsewhere on the board
/LTDC TFT LCD/LTDC_G5: U1.131 (PI0); also elsewhere on the board
/LTDC TFT LCD/LTDC_G6: U1.132 (PI1); also elsewhere on the board
/LTDC TFT LCD/LTDC_G7: U1.133 (PI2); also elsewhere on the board
/LTDC TFT LCD/LTDC_HSYNC: U1.12 (PI10); also elsewhere on the board
/LTDC TFT LCD/LTDC_PCLK: U1.111 (PG7); also elsewhere on the board
/LTDC TFT LCD/LTDC_R0: U1.43 (PH2); also elsewhere on the board
/LTDC TFT LCD/LTDC_R1: U1.44 (PH3); also elsewhere on the board
/LTDC TFT LCD/LTDC_R2: U1.85 (PH8); also elsewhere on the board
/LTDC TFT LCD/LTDC_R3: U1.86 (PH9); also elsewhere on the board
/LTDC TFT LCD/LTDC_R4: U1.87 (PH10); also elsewhere on the board
/LTDC TFT LCD/LTDC_R5: U1.88 (PH11); also elsewhere on the board
/LTDC TFT LCD/LTDC_R6: U1.89 (PH12); also elsewhere on the board
/LTDC TFT LCD/LTDC_R7: U1.110 (PG6); also elsewhere on the board
/LTDC TFT LCD/LTDC_VSYNC: U1.11 (PI9); also elsewhere on the board
/LTDC TFT LCD/TOUCH_INT: U1.134 (PI3); also elsewhere on the board
/LTDC TFT LCD/TOUCH_SCL: R8.1, U1.167 (PB8); also elsewhere on the board
/LTDC TFT LCD/TOUCH_SDA: R9.1, U1.168 (PB9); also elsewhere on the board
/MCU/ETH_CLKEN: U1.79 (PB10); also elsewhere on the board
/MCU/ETH_REFCLK: U1.41 (PA1); also elsewhere on the board
/MCU/FLASH_CS: U1.24 (PF6); also elsewhere on the board
/MCU/RMII_CRS_DV: U1.53 (PA7); also elsewhere on the board
/MCU/RMII_MDC: U1.33 (PC1); also elsewhere on the board
/MCU/RMII_MDIO: U1.42 (PA2); also elsewhere on the board
/MCU/RMII_RXD0: U1.54 (PC4); also elsewhere on the board
/MCU/RMII_RXD1: U1.55 (PC5); also elsewhere on the board
/MCU/RMII_TXD0: U1.92 (PB12); also elsewhere on the board
/MCU/RMII_TXD1: U1.93 (PB13); also elsewhere on the board
/MCU/RMII_TXEN: U1.80 (PB11); also elsewhere on the board
/MCU/RS485_TE: U1.151 (PD7); also elsewhere on the board
/MCU/SDIO_CLK: U1.141 (PC12); also elsewhere on the board
/MCU/SDIO_CMD: U1.144 (PD2); also elsewhere on the board
/MCU/SDIO_D0: U1.117 (PC8); also elsewhere on the board
/MCU/SDIO_D1: U1.118 (PC9); also elsewhere on the board
/MCU/SDIO_D2: U1.139 (PC10); also elsewhere on the board
/MCU/SDIO_D3: U1.140 (PC11); also elsewhere on the board
/MCU/SDRAM_A0: U1.16 (PF0); also elsewhere on the board
/MCU/SDRAM_A1: U1.17 (PF1); also elsewhere on the board
/MCU/SDRAM_A2: U1.18 (PF2); also elsewhere on the board
/MCU/SDRAM_A3: U1.19 (PF3); also elsewhere on the board
/MCU/SDRAM_A4: U1.20 (PF4); also elsewhere on the board
/MCU/SDRAM_A5: U1.21 (PF5); also elsewhere on the board
/MCU/SDRAM_A6: U1.60 (PF12); also elsewhere on the board
/MCU/SDRAM_A7: U1.63 (PF13); also elsewhere on the board
/MCU/SDRAM_A8: U1.64 (PF14); also elsewhere on the board
/MCU/SDRAM_A9: U1.65 (PF15); also elsewhere on the board
/MCU/SDRAM_A10: U1.66 (PG0); also elsewhere on the board
/MCU/SDRAM_A11: U1.67 (PG1); also elsewhere on the board
/MCU/SDRAM_BA0: U1.108 (PG4); also elsewhere on the board
/MCU/SDRAM_BA1: U1.109 (PG5); also elsewhere on the board
/MCU/SDRAM_CKE: U1.35 (PC3); also elsewhere on the board
/MCU/SDRAM_CLK: U1.112 (PG8); also elsewhere on the board
/MCU/SDRAM_D0: U1.104 (PD14); also elsewhere on the board
/MCU/SDRAM_D1: U1.105 (PD15); also elsewhere on the board
/MCU/SDRAM_D2: U1.142 (PD0); also elsewhere on the board
/MCU/SDRAM_D3: U1.143 (PD1); also elsewhere on the board
/MCU/SDRAM_D4: U1.68 (PE7); also elsewhere on the board
/MCU/SDRAM_D5: U1.69 (PE8); also elsewhere on the board
/MCU/SDRAM_D6: U1.70 (PE9); also elsewhere on the board
/MCU/SDRAM_D7: U1.73 (PE10); also elsewhere on the board
/MCU/SDRAM_D8: U1.74 (PE11); also elsewhere on the board
/MCU/SDRAM_D9: U1.75 (PE12); also elsewhere on the board
/MCU/SDRAM_D10: U1.76 (PE13); also elsewhere on the board
/MCU/SDRAM_D11: U1.77 (PE14); also elsewhere on the board
/MCU/SDRAM_D12: U1.78 (PE15); also elsewhere on the board
/MCU/SDRAM_D13: U1.96 (PD8); also elsewhere on the board
/MCU/SDRAM_D14: U1.97 (PD9); also elsewhere on the board
/MCU/SDRAM_D15: U1.98 (PD10); also elsewhere on the board
/MCU/SDRAM_NBL0: U1.169 (PE0); also elsewhere on the board
/MCU/SDRAM_NBL1: U1.170 (PE1); also elsewhere on the board
/MCU/SDRAM_NCAS: U1.160 (PG15); also elsewhere on the board
/MCU/SDRAM_NE: U1.34 (PC2); also elsewhere on the board
/MCU/SDRAM_NRAS: U1.59 (PF11); also elsewhere on the board
/MCU/SDRAM_NWE: U1.32 (PC0); also elsewhere on the board
/MCU/SPI1_MISO: U1.26 (PF8); also elsewhere on the board
/MCU/SPI1_MOSI: U1.27 (PF9); also elsewhere on the board
/MCU/SPI1_SCK: U1.25 (PF7); also elsewhere on the board
/MCU/USART1_RX: U1.121 (PA10); also elsewhere on the board
/MCU/USART1_TX: U1.120 (PA9); also elsewhere on the board
/MCU/USART2_RX: U1.150 (PD6); also elsewhere on the board
/MCU/USART2_TX: U1.147 (PD5); also elsewhere on the board
/MCU/USB_OTG_DM: U1.122 (PA11); also elsewhere on the board
/MCU/USB_OTG_DP: U1.123 (PA12); also elsewhere on the board
BOOT0: JP3.2 (C), R3.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C59.1, C60.1, C61.1, C118.1, J4.6, JP3.3 (B), R7.1, SW1.1, U1.14 (VSS), U1.22 (VSS), U1.37 (VSSA), U1.48 (BYPASS_REG), U1.61 (VSS), U1.71 (VSS), U1.90 (VSS), U1.102 (VSS), U1.113 (VSS), U1.126 (VSS), U1.135 (VSS), U1.148 (VSS), U1.158 (VSS), Y1.2, Y1.3, Y2.2, Y2.4; also elsewhere on the board
HSEI: C8.2, R6.1, U1.29 (PH0), Y2.1
HSEO: C9.2, R6.2, U1.30 (PH1), Y2.3
LOG_RX: J4.4
LOG_TX: J4.2
LSEI: C7.2, U1.9 (PC14), Y1.4
LSEO: C6.2, U1.10 (PC15), Y1.1
unnamed: C1.2, R4.1, SW1.2, U1.31 (NRST)
unnamed: C2.2, U1.81 (VCAP_1)
unnamed: C3.2, U1.125 (VCAP_2)
unnamed: C4.2, C5.2, R11.2, U1.38 (VREF+)
unnamed: D1.1 (K), R7.2
unnamed: R3.2, U1.166 (BOOT0)
STATUS LED: D1.2 (A), U1.8 (PC13)
SWCLK: J4.5, U1.137 (PA14)
SWDIO: J4.3, U1.124 (PA13)

Parts:
C22, C27, C38: 1uF; C_0603_1608Metric
C23, C24, C28, C29, C30, C31, C34, C35, C36, C37, C39, C40: 100nF; C_0603_1608Metric
C25, C26: C_Small; C_0603_1608Metric
C70, C89: 10uF; C_1206_3216Metric
D2: LED_WIFI; LED_0603_1608Metric
J3: ESP Anten; Connector_Coaxial_SMA
L1, L2: L_Small; L_0603_1608Metric
R17, R18, R21, R22, R23, R33: R_Small; R_0603_1608Metric
SW2: ESP_RESET; SW_SPST_CK_RS282G05A3
SW3: ESP_BOOT; SW_SPST_CK_RS282G05A3
U4: ESP32-D0WD-V3; ESP32-QFN48
U5: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm
Y3: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/MCU/USART1_RX: R22.1; also elsewhere on the board
/MCU/USART1_TX: R23.1; also elsewhere on the board
/USB/RXD: U4.41 (U0TXD); also elsewhere on the board
/USB/TXD: U4.40 (U0RXD); also elsewhere on the board
/USB/WiFi_BOOT: C26.2, R18.1, SW3.2, U4.23 (GPIO0); also elsewhere on the board
/USB/WiFi_RST: C25.2, R17.1, SW2.2, U4.9 (CHIP_PU); also elsewhere on the board
/WIFI ESP32/ETH_CLKEN: U4.24 (GPIO4); also elsewhere on the board
/WIFI ESP32/F_CLK: U4.31 (SD_CLK), U5.6 (CLK)
/WIFI ESP32/F_CMD: U4.30 (SD_CMD), U5.1 (~CS)
/WIFI ESP32/F_D0: U4.32 (SD_D0), U5.5 (DI(IO0))
/WIFI ESP32/F_D1: U4.33 (SD_D1), U5.2 (DO(IO1))
/WIFI ESP32/F_D2: U4.28 (SD_D2), U5.3 (IO2)
/WIFI ESP32/F_D3: U4.29 (SD_D3), U5.7 (IO3)
/WIFI ESP32/RMII_CRSDV: U4.16 (GPIO27); also elsewhere on the board
/WIFI ESP32/RMII_MDC: U4.36 (GPIO23); also elsewhere on the board
/WIFI ESP32/RMII_MDIO: U4.35 (GPIO18); also elsewhere on the board
/WIFI ESP32/RMII_RXD0: U4.14 (GPIO25); also elsewhere on the board
/WIFI ESP32/RMII_RXD1: U4.15 (GPIO26); also elsewhere on the board
/WIFI ESP32/RMII_TXD0: U4.38 (GPIO19); also elsewhere on the board
/WIFI ESP32/RMII_TXD1: U4.39 (GPIO22); also elsewhere on the board
/WIFI ESP32/RMII_TXEN: U4.42 (GPIO21); also elsewhere on the board
GND: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.2, C30.1, C31.1, C34.2, C36.2, C37.2, C38.1, C39.1, C40.1, C70.1, C89.1, J3.2 (Ext), R33.1, SW2.1, SW3.1, U4.49 (GND_PAD), U5.4 (GND), Y3.2, Y3.4; also elsewhere on the board
unnamed: C29.1, J3.1 (In), L1.1
unnamed: C30.2, L2.2, U4.3 (VDD), U4.4 (VDD)
unnamed: C31.2, L1.2, U4.2 (LNA_IN)
unnamed: C34.1, C35.2, R21.2, U4.48 (CAP1)
unnamed: C35.1, R21.1, U4.47 (CAP2)
unnamed: C36.1, U4.45 (XTAL_P), Y3.1
unnamed: C37.1, U4.44 (XTAL_N), Y3.3
unnamed: D2.1 (K), R33.2
unnamed: D2.2 (A), U4.22 (GPIO2)
unnamed: R22.2, U4.27 (GPIO17)
unnamed: R23.2, U4.25 (GPIO16)

Parts:
J2: Micro_SD_Card; MicroSD_Socket
R5, R12, R14, R15, R16: R_Small; R_0603_1608Metric

Connections:
/MCU/SDIO_CLK: J2.5 (CLK); also elsewhere on the board
/MCU/SDIO_CMD: J2.3 (CMD), R14.2; also elsewhere on the board
/MCU/SDIO_D0: J2.7 (DAT0), R12.2; also elsewhere on the board
/MCU/SDIO_D1: J2.8 (DAT1), R5.2; also elsewhere on the board
/MCU/SDIO_D2: J2.1 (DAT2), R16.2; also elsewhere on the board
/MCU/SDIO_D3: J2.2 (DAT3/CD), R15.2; also elsewhere on the board
GND: J2.6 (VSS), J2.9 (SHIELD); also elsewhere on the board

Schematic: USB.kicad_sch

Parts:
C117: C_Small; C_0603_1608Metric
D11, D12: SS34; D_SMA
J10: USB_OTG; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J11: USB_WIFI_FLASH; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Q2, Q3: BC847; SOT-23
R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68: R_Small; R_0603_1608Metric
U9: CP2102N; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U11, U12: USBLC6-2SC6; SOT-23-6

Connections:
+5V: D11.1 (K), D12.1 (K), R65.2, U9.7 (VREGIN), U9.8 (VBUS), U11.5 (VBUS), U12.5 (VBUS); also elsewhere on the board
/MCU/USB_OTG_DM: R61.2; also elsewhere on the board
/MCU/USB_OTG_DP: R62.2; also elsewhere on the board
/USB/RXD: U9.25 (RXD); also elsewhere on the board
/USB/TXD: R66.1; also elsewhere on the board
/USB/WiFi_BOOT: Q3.3 (C); also elsewhere on the board
/USB/WiFi_RST: Q2.3 (C); also elsewhere on the board
GND: C117.2, J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.S1 (SHIELD), J11.A1 (GND), J11.A12 (GND), J11.B1 (GND), J11.B12 (GND), J11.S1 (SHIELD), R58.2, R59.2, R63.2, R64.2, U9.3 (GND), U9.29 (GND), U11.2 (GND), U12.2 (GND); also elsewhere on the board
unnamed: C117.1, U9.6 (VDD)
unnamed: D11.2 (A), J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS)
unnamed: D12.2 (A), J11.A4 (VBUS), J11.A9 (VBUS), J11.B4 (VBUS), J11.B9 (VBUS)
unnamed: J10.A5 (CC1), R58.1
unnamed: J10.A6 (D+), J10.B6 (D+), R60.1, R62.1, U11.3 (I/O2), U11.4 (I/O2)
unnamed: J10.A7 (D-), J10.B7 (D-), R61.1, U11.1 (I/O1), U11.6 (I/O1)
unnamed: J10.B5 (CC2), R59.1
unnamed: J11.A5 (CC1), R63.1
unnamed: J11.A6 (D+), J11.B6 (D+), U9.4 (D+), U12.1 (I/O1), U12.6 (I/O1)
unnamed: J11.A7 (D-), J11.B7 (D-), U9.5 (D-), U12.3 (I/O2), U12.4 (I/O2)
unnamed: J11.B5 (CC2), R64.1
unnamed: Q2.1 (B), R67.1
unnamed: Q2.2 (E), R68.2, U9.28 (~DTR)
unnamed: Q3.1 (B), R68.1
unnamed: Q3.2 (E), R67.2, U9.24 (~RTS)
unnamed: R65.1, U9.9 (~RST)
unnamed: R66.2, U9.26 (TXD)
