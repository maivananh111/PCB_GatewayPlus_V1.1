# Repository maivananh111/PCB_GatewayPlus_V1.1 (continued)

## KiCad design GatewayPlus_V1.1.kicad_pcb (continued)

Schematic: SDRAM.kicad_sch

Parts:
C41, C44: 1uF; C_0603_1608Metric
C42, C43, C45, C46, C90: 100nF; C_0603_1608Metric
U2: IS42S16400J - HY57V641620E; TSOP-II-54_22.2x10.16mm_P0.8mm

Connections:
/MCU/SDRAM_A0: U2.23 (A0); also elsewhere on the board
/MCU/SDRAM_A1: U2.24 (A1); also elsewhere on the board
/MCU/SDRAM_A2: U2.25 (A2); also elsewhere on the board
/MCU/SDRAM_A3: U2.26 (A3); also elsewhere on the board
/MCU/SDRAM_A4: U2.29 (A4); also elsewhere on the board
/MCU/SDRAM_A5: U2.30 (A5); also elsewhere on the board
/MCU/SDRAM_A6: U2.31 (A6); also elsewhere on the board
/MCU/SDRAM_A7: U2.32 (A7); also elsewhere on the board
/MCU/SDRAM_A8: U2.33 (A8); also elsewhere on the board
/MCU/SDRAM_A9: U2.34 (A9); also elsewhere on the board
/MCU/SDRAM_A10: U2.22 (A10); also elsewhere on the board
/MCU/SDRAM_A11: U2.35 (A11); also elsewhere on the board
/MCU/SDRAM_BA0: U2.20 (BA0); also elsewhere on the board
/MCU/SDRAM_BA1: U2.21 (BA1); also elsewhere on the board
/MCU/SDRAM_CKE: U2.37 (CKE); also elsewhere on the board
/MCU/SDRAM_CLK: U2.38 (CLK); also elsewhere on the board
/MCU/SDRAM_D0: U2.2 (DQ0); also elsewhere on the board
/MCU/SDRAM_D1: U2.4 (DQ1); also elsewhere on the board
/MCU/SDRAM_D2: U2.5 (DQ2); also elsewhere on the board
/MCU/SDRAM_D3: U2.7 (DQ3); also elsewhere on the board
/MCU/SDRAM_D4: U2.8 (DQ4); also elsewhere on the board
/MCU/SDRAM_D5: U2.10 (DQ5); also elsewhere on the board
/MCU/SDRAM_D6: U2.11 (DQ6); also elsewhere on the board
/MCU/SDRAM_D7: U2.13 (DQ7); also elsewhere on the board
/MCU/SDRAM_D8: U2.42 (DQ8); also elsewhere on the board
/MCU/SDRAM_D9: U2.44 (DQ9); also elsewhere on the board
/MCU/SDRAM_D10: U2.45 (DQ10); also elsewhere on the board
/MCU/SDRAM_D11: U2.47 (DQ11); also elsewhere on the board
/MCU/SDRAM_D12: U2.48 (DQ12); also elsewhere on the board
/MCU/SDRAM_D13: U2.50 (DQ13); also elsewhere on the board
/MCU/SDRAM_D14: U2.51 (DQ14); also elsewhere on the board
/MCU/SDRAM_D15: U2.53 (DQ15); also elsewhere on the board
/MCU/SDRAM_NBL0: U2.15 (LDQM); also elsewhere on the board
/MCU/SDRAM_NBL1: U2.39 (UDQM); also elsewhere on the board
/MCU/SDRAM_NCAS: U2.17 (~CAS); also elsewhere on the board
/MCU/SDRAM_NE: U2.19 (~CS); also elsewhere on the board
/MCU/SDRAM_NRAS: U2.18 (~RAS); also elsewhere on the board
/MCU/SDRAM_NWE: U2.16 (~WE); also elsewhere on the board
GND: C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C90.1, U2.6 (GNDQ), U2.12 (GNDQ), U2.28 (GND), U2.41 (GND), U2.46 (GNDQ), U2.52 (GNDQ), U2.54 (GND); also elsewhere on the board

Schematic: RF-LORA-ZIGBEE.kicad_sch

Parts:
C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116: C_Small; C_0603_1608Metric
J9: LoRa_Anten; Connector_Coaxial_SMA
L6, L7, L8, L9, L10, L11, L12: L_Small; L_0603_1608Metric
Q1: BC847; SOT-23
R55, R56, R57: R_Small; R_0603_1608Metric
U6: SX1278; QFN-28-1EP_6x6mm_P0.65mm_EP4.8x4.8mm
U10: MASWSS0192; SOT-363_SC-70-6
Y4: 32MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/RF-LORA-ZIGBEE/LoRa_IRQ: U6.8 (DIO0)
/RF-LORA-ZIGBEE/LoRa_MISO: U6.17 (MISO)
/RF-LORA-ZIGBEE/LoRa_MOSI: U6.18 (MOSI)
/RF-LORA-ZIGBEE/LoRa_NSS: U6.19 (NSS)
/RF-LORA-ZIGBEE/LoRa_RST: U6.7 (~RESET)
/RF-LORA-ZIGBEE/LoRa_SCK: U6.16 (SCK)
GND: C91.2, C92.1, C93.1, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C102.2, C104.2, C106.2, C108.1, C110.1, C112.1, C113.1, C114.1, C115.1, C116.1, J9.2 (Ext), L6.2, Q1.2 (E), U6.15 (GND), U6.21 (GND), U6.22 (GND), U6.23 (GND), U6.26 (GND), U6.29 (GND), U10.2 (GND), Y4.2, Y4.4; also elsewhere on the board
unnamed: C92.2, U6.5 (XTA), Y4.3
unnamed: C93.2, U6.6 (XTB), Y4.1
unnamed: C99.1, U6.4 (VR_DIG)
unnamed: C100.1, U6.2 (VR_ANA)
unnamed: C101.1, C102.1, C104.1, L9.2, U6.25 (VR_PA)
unnamed: C103.1, L7.2
unnamed: C103.2, C105.1
unnamed: C105.2, U10.1 (RF1)
unnamed: C106.1, C107.1, L8.2, L9.1
unnamed: C107.2, C108.2, C109.1, L10.1
unnamed: C109.2, C110.2, C111.1, L10.2, L11.1
unnamed: C111.2, C112.2, L11.2, U10.3 (RF2)
unnamed: C113.2, Q1.3 (C), R57.1, U10.4 (V2)
unnamed: C114.2, R55.2, U10.6 (V1)
unnamed: C115.2, L12.1, U10.5 (RFC)
unnamed: C116.2, J9.1 (In), L12.2
unnamed: L6.1, L7.1, U6.1 (RFI_LF)
unnamed: L8.1, U6.27 (PA_BOOST)
unnamed: Q1.1 (B), R56.2
unnamed: R55.1, R56.1, U6.20 (RXTX/RF_MOD)

Schematic: AUDIO.kicad_sch

Parts:
J8: AudioJack4; AudioJack_3.5mm_PJ-320

Connections:
/AUDIO/Audio_Left: J8.T
/AUDIO/Audio_Right: J8.R1
GND: J8.R2, J8.S; also elsewhere on the board

Schematic: ETH.kicad_sch

Parts:
C32, C33, C62, C63, C64, C65, C66, C67, C68: C_Small; C_0603_1608Metric
C69: C_Small; C_1206_3216Metric
J5: HR911105A; RJ45_Hanrun_HR911105A
JP1: PHYADDR; Jump3_0603_Open
L3: L_Small; L_0603_1608Metric
R1, R2, R13, R19, R20, R24, R25, R26, R27, R28, R29, R30, R31, R32: R_Small; R_0603_1608Metric
U7: LAN8720A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
X1: 50MHz; Oscillator_SMD_Abracon_ASV-4Pin_7.0x5.1mm

Connections:
/ETH/ETH_CLKEN: R13.2, R19.1, X1.1 (EN); also elsewhere on the board
/ETH/ETH_REFCLK: U7.14 (INT/REFCLKO); also elsewhere on the board
/ETH/RMII_CRS_DV: U7.11 (CRS_DV/MODE2); also elsewhere on the board
/ETH/RMII_MDC: U7.13 (MDC); also elsewhere on the board
/ETH/RMII_MDIO: R1.2, U7.12 (MDIO); also elsewhere on the board
/ETH/RMII_RXD0: U7.8 (RXD0/MODE0); also elsewhere on the board
/ETH/RMII_RXD1: U7.7 (RXD1/MODE1); also elsewhere on the board
/ETH/RMII_TXD0: U7.17 (TXD0); also elsewhere on the board
/ETH/RMII_TXD1: U7.18 (TXD1); also elsewhere on the board
/ETH/RMII_TXEN: U7.16 (TXEN); also elsewhere on the board
GND: C32.1, C33.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, J5.8, J5.11, J5.SH (SHIELD), JP1.1 (A), R19.2, R20.2, R25.2, R27.2, U7.25 (VSS), X1.2 (GND); also elsewhere on the board
unnamed: C32.2, R2.2, U7.15 (RST)
unnamed: C63.2, C64.2, U7.6 (VDDCR)
unnamed: C65.2, C66.2, L3.2, U7.1 (VDD2A), U7.19 (VDD1A)
unnamed: J5.1, R29.2, U7.21 (TXP)
unnamed: J5.2, R28.2, U7.20 (TXN)
unnamed: J5.3, R26.2, U7.23 (RXP)
unnamed: J5.6, R24.2, U7.22 (RXN)
unnamed: J5.9, R30.2
unnamed: J5.12, R31.2
unnamed: JP1.2 (C), U7.10 (RXER/PHYAD0)
unnamed: R20.1, U7.24 (RBIAS)
unnamed: R25.1, R31.1, U7.2 (LED2/nINTSEL)
unnamed: R27.1, R30.1, U7.3 (LED1/REGOFF)
unnamed: R32.1, U7.5 (XTAL1/CLKIN)
unnamed: R32.2, X1.3 (OUT)

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
Board: 2 copper layers, 100.0 x 67.0 mm, 268 parts (8 on the bottom side), 234 nets.

## Commit log

2023-02-14 Finish SDRAM layout.
2023-02-15 Finish SDRAM, LCD, Power block.
2023-02-15 New SDRAM layout.
2023-02-16 Finish USB, LoRa Layout
2023-02-16 Finish LTDC LCD Layout
2023-02-18 Create Audio CODEC schematic block and layout.
2023-02-19 Only 1 wire to complete.
2023-02-20 Power route bug.
